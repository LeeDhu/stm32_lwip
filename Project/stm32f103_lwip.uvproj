# Keil uVision project stm32f103_lwip.uvproj, settings and files
target Stm32F103_lwip_v1.0 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103_lwip +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\LWIP\src\api;..\LWIP\src\core;..\LWIP\src\include;..\USER;..\LWIP\src\include\ipv4;..\LWIP\src\include\netif;..\LWIP\src\include\lwip;..\LWIP\src\arch;..\LWIP\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../USER/: stm32f10x_it.c main.c enc28j60.c spi.c usart.c ticks.c tcp_server.c lwip.c
  group LWIP_ARCH
    ../LWIP/src/arch/: cc.h lwipopts.h perf.h sys_arch.c
  group LWIP_CORE
    ../LWIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_IPV4
    ../LWIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_SNMP
    ../LWIP/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group LWIP_API
    ../LWIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_NETIF
    ../LWIP/src/netif/: etharp.c ethernetif.c slipif.c
